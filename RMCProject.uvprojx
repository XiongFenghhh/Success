# Keil uVision project RMCProject.uvprojx, settings and files
target RMPRoject (ARM-ADS)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RMCProject
  c flags: Optim=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F429_439xx,Shooter1
  c include: ..\RMCProject;.\RM_Encoder;.\RM_Motor;.\RM_Remoter;.\RM_Debug;.\RM_Yuntai;.\STM32F4xx\Include;.\STM32F4xx_StdPeriph_Driver\inc;.\CMSIS\Include;.\STM32F429I-Discovery;.\RM_Posture;..\RMCProject531253
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Motor
    ./RM_Motor/: BatholithTimer.c MotorEngine.c
  group RemoteController
    ./RM_Remoter/: RemoteController.c
  group Encoder
    ./RM_Encoder/: Encoder.c
  group Yuntai
    ./RM_Yuntai/: app.c can.c stepper.c brushlessMotor.c usart3.c
  group OfficialLib
    ./STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_flash.c misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_dac.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c stm32f4xx_pwr.c
  group TeamCode
    ./STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ./: main.c stm32f4xx_it.c RMVariables.c
  group Start
    ./STM32F4xx/Source/Templates/arm/: startup_stm32f429_439xx.s
  group DebugTools
    ./RM_Debug/: RMflash.c
  group Posture
    ./RM_Posture/: mpu6050_driver.c mpu6050_i2c.c mpu6050_interrupt.c mpu6050_process.c AHRS_Attitude.c AHRS_Attitude.h mpu9150.c mpu9150.h STM32_I2C.c STM32_I2C.h inv_mpu.c inv_mpu.h inv_mpu_dmp_motion_driver.c inv_mpu_dmp_motion_driver.h dmpKey.h dmpmap.h Time.c Time.h
